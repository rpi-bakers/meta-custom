DISTRO_FEATURES:append = " wayland "

IMAGE_INSTALL:append = " \
    weston \
    xwayland \
    \
    xauth \
    mono \
    mono-libs \
    dotnet \
    samba \
    xterm \
    xeyes \
    xclock \
    gtk+ \
    \
"