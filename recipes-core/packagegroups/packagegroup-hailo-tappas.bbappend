
# taapas-apps recipe has been removed from recipes-gstreamer.
RDEPENDS:${PN}-dev-pkg = " \
    packagegroup-hailo-tappas \
    tappas-tracers \
    opencv \
"
