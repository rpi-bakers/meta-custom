FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
    file://0001-gmacros-Define-G_PASTE-G_PASTE_ARGS-for-GI-Scanner.patch \
"
