do_install:append() {
  # Generated by CMake and embeds build-time TMPDIR paths; remove to satisfy buildpaths QA.
  rm -f ${D}${libdir}/cmake/HailoRT/cmake_install.cmake
}
