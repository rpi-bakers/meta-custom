SRC_URI = "git://github.com/xtensor-stack/xtl.git;name=xtl;protocol=https;branch=master"
