# Recipe LICENSE includes obsolete licenses LGPLv2.1
LICENSE = "LGPL-2.1-only"
