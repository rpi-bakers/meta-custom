PACKAGECONFIG:append:pn-qemu-system-native = " sdl"
