# Ensure create-spdx can always find MINPACK license text from recipe sources.
NO_GENERIC_LICENSE[MINPACK] = "COPYING.MINPACK"
