PACKAGECONFIG:append:pn-neatvnc = " tls"
